# Keil uVision project event.uvprojx, settings and files
target event hello (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: fmeter +hex
  c flags: Optim=1 wLevel=2
  c define: BIG MENU_DEMO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Src
    ./: startup_stm32f030.s n1202.c event.c
software components: CMSIS:CORE 3.40.0
